v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {ipin.sym} -30 -20 0 0 {name=p1 lab=spdif_in}
C {opin.sym} 40 -60 0 0 {name=p2 lab=i2s_bclk}
C {ipin.sym} -30 10 0 0 {name=p3 lab=VPWR}
C {ipin.sym} -30 30 2 1 {name=p4 lab=VGND}
C {ipin.sym} -30 -40 0 0 {name=p5 lab=rst_n}
C {ipin.sym} -30 -60 0 0 {name=p6 lab=clk}
C {opin.sym} 40 -40 0 0 {name=p7 lab=i2s_ws}
C {opin.sym} 40 -20 0 0 {name=p8 lab=i2s_sd}
C {opin.sym} 40 0 0 0 {name=p9 lab=mute}
C {opin.sym} 40 20 0 0 {name=p10 lab=locked}
C {opin.sym} 40 40 0 0 {name=p11 lab=block_start}
C {opin.sym} 40 60 0 0 {name=p12 lab=pwm_out}
